# IAR project mmc_boot.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=0; CPU_IS_ARM_CORTEX_M33=1; MCUXPRESSO_SDK; BL_TARGET_RAM; SDK_OS_BAREMETAL
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe177,Pe186,Ms014,Pa182
  ICCARM.CCIncludePath2: 
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  AARM.AUserIncludes: ../../../../../middleware/mcu_bootloader/src/startup
  OBJCOPY.OOCOutputFile: mmc_boot.srec
  ILINK.IlinkOutputFile: mmc_boot.out
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group source
    ./: bl_main.c bl_usdhc.c bl_usdhc.h bootloader_common.h clock_config_MIMXRT685S.c cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h fsl_clock.c fsl_clock.h fsl_common.h fsl_device_registers.h fsl_gpio.c fsl_gpio.h fsl_mmc.c fsl_mmc.h fsl_reset.c fsl_reset.h fsl_sdmmc_common.c fsl_sdmmc_common.h fsl_sdmmc_host.c fsl_sdmmc_host.h fsl_sdmmc_spec.h hardware_init_MIMXRT685S.c memory.c memory.h microseconds.h microseconds_sysclk.c MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h mmc_memory.c mmc_memory.h mpu_armv8.h property.h sdmmc_config_MIMXRT685S.c sdmmc_init.h startup.c startup_MIMXRT685S_cm33.s system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h tz_context.h
