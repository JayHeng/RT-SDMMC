<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\mmccard_bm.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>mmccard_freertos</project>
                <configuration>sdram_debug</configuration>
            </member>
            <member>
                <project>mmccard_freertos</project>
                <configuration>sdram_release</configuration>
            </member>
            <member>
                <project>mmccard_freertos</project>
                <configuration>release</configuration>
            </member>
            <member>
                <project>mmccard_freertos</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>mmccard_freertos</project>
                <configuration>flexspi_nor_debug</configuration>
            </member>
            <member>
                <project>mmccard_freertos</project>
                <configuration>flexspi_nor_release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>sdram_debug</name>
            <member>
                <project>mmccard_freertos</project>
                <configuration>sdram_debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>sdram_release</name>
            <member>
                <project>mmccard_freertos</project>
                <configuration>sdram_release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>release</name>
            <member>
                <project>mmccard_freertos</project>
                <configuration>release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>debug</name>
            <member>
                <project>mmccard_freertos</project>
                <configuration>debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flexspi_nor_debug</name>
            <member>
                <project>mmccard_freertos</project>
                <configuration>flexspi_nor_debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flexspi_nor_release</name>
            <member>
                <project>mmccard_freertos</project>
                <configuration>flexspi_nor_release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
