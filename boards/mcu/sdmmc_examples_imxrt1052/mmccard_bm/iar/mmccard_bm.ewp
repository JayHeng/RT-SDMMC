# IAR project mmccard_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1052DVL6B; MCUXPRESSO_SDK; MMC_ENABLED; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MIMXRT1052/drivers; ../../../../../middleware/sdmmc/host/usdhc; ../../../../../middleware/sdmmc/mmc; ../../../../../components/gpio; ../../../../../rtos/freertos/freertos-kernel/include; ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../../../../devices/MIMXRT1052; ../../../../../devices/MIMXRT1052/utilities/str; ../../../../../devices/MIMXRT1052/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MIMXRT1052/utilities; ../../../../../devices/MIMXRT1052/xip; ../../../xip; ../../../../../middleware/sdmmc/common; ../../../../../middleware/sdmmc/osa; ../../../../../components/osa; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: mmccard_freertos.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1052DVL6B; MCUXPRESSO_SDK; MMC_ENABLED; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1052DVL6B; MCUXPRESSO_SDK; MMC_ENABLED; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1052DVL6B; MCUXPRESSO_SDK; MMC_ENABLED; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1052DVL6B; MCUXPRESSO_SDK; MMC_ENABLED; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; NDEBUG; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1052DVL6B; MCUXPRESSO_SDK; MMC_ENABLED; SDK_OS_FREE_RTOS; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h sdmmc_config.c sdmmc_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cachel1_armv7.h cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/gpio
    ../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_usdhc.c fsl_usdhc.h
  group freertos/freertos-kernel
    ../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos-kernel/portable
    ../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/: ChangeLogKSDK.txt fsl_sdmmc_host.h
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/mmc/: fsl_mmc.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group sdmmc/mmc
    ../../../../../middleware/sdmmc/mmc/: ChangeLogKSDK.txt
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
  group sdmmc/src
    ../../../../../middleware/sdmmc/mmc/: fsl_mmc.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group source
    ../: FreeRTOSConfig.h mmccard_bm.c
  group startup
    ../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c fsl_assert.h
    ../../../../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h
    ../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
