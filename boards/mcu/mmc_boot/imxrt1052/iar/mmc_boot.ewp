# IAR project mmc_boot.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1052DVL6B; CPU_IS_ARM_CORTEX_M7=1; BL_TARGET_RAM; MIMXRT1052; USB_STACK_BM; SDK_OS_BAREMETAL
  ICCARM.CCDiagSuppress: Pa082,Pe177,Pe186,Ms014,Pa182
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MIMXRT1052; ../../../../../devices/MIMXRT1052/drivers; ../../../../../middleware/mcu_bootloader/src/bootloader; ../../../../../middleware/mcu_bootloader/src/include; ../../../../../middleware/mcu_bootloader/src/memory; ../../../../../middleware/mcu_bootloader/src/memory/src; ../../../../../middleware/mcu_bootloader/src/startup; ../../../../../middleware/mcu_bootloader/src/property; ../../../../../middleware/mcu_bootloader/src/utilities; ../../../../../middleware/mcu_bootloader/targets/MIMXRT1052/src; ../../../../../middleware/mcu_bootloader/src/drivers/microseconds; ../../../../../middleware/mcu_bootloader/src/drivers/ocotp; ../../../../../CMSIS/Core/Include; ../../../../../components/osa; ../../../../../components/lists; ../../../../../middleware/mcu_bootloader/src; ../../../../../middleware/mcu_bootloader/src/drivers/; ../../../../../middleware/mcu_bootloader/src/drivers/usdhc; ../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  AARM.AUserIncludes: ../../../../../middleware/mcu_bootloader/src/startup
  OBJCOPY.OOCOutputFile: mmc_boot.srec
  ILINK.IlinkOutputFile: mmc_boot.out
  ILINK.IlinkIcfFile: MIMXRT1052_ram_flashloader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cachel1_armv7.h cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group device
    ../../../../../devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.h
    ../../../../../middleware/mcu_bootloader/targets/MIMXRT1052/src/startup/: system_MIMXRT1052.c
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpspi.c fsl_lpspi.h fsl_lpuart.c fsl_lpuart.h
  group MIMXRT1052
    ../../../../../middleware/mcu_bootloader/targets/MIMXRT1052/src/: bl_clock_config_MIMXRT1052.c bootloader_config.h external_memory_property_map_MIMXRT1052.c fusemap.h hardware_init_MIMXRT1052.c memory_map_MIMXRT1052.c peripherals_pinmux.h sdmmc_config_MIMXRT1052.c sdmmc_init.h sram_init_MIMXRT1052.c target_config.h
  group source/bootloader
    ../../../../../middleware/mcu_bootloader/src/bootloader/: bl_context.h bl_shutdown_cleanup.h bootloader.h
  group source/bootloader/src
    ../../../../../middleware/mcu_bootloader/src/bootloader/src/: bl_context.c bl_exception_handler.c bl_main.c bl_shutdown_cleanup.c
  group source/drivers/microseconds
    ../../../../../middleware/mcu_bootloader/src/drivers/microseconds/: microseconds.h
    ../../../../../middleware/mcu_bootloader/src/drivers/microseconds/src/: microseconds_pit.c
  group source/drivers/sdmmc
    ../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/src/: fsl_mmc.c fsl_sd.c fsl_sdmmc_common.c
    ../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/inc/: fsl_mmc.h fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
    ../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/port/usdhc/polling/: fsl_sdmmc_host.c
  group source/drivers/usdhc
    ../../../../../middleware/mcu_bootloader/src/drivers/usdhc/: bl_usdhc.c bl_usdhc.h
  group source/include
    ../../../../../middleware/mcu_bootloader/src/include/: bootloader_common.h bootloader_core.h
  group source/memory
    ../../../../../middleware/mcu_bootloader/src/memory/: memory.h
  group source/memory/src
    ../../../../../middleware/mcu_bootloader/src/memory/src/: memory.c mmc_memory.c mmc_memory.h normal_memory.c normal_memory.h pattern_fill.h pattern_fill.s sd_memory.c sd_memory.h sram_init.h
  group source/property
    ../../../../../middleware/mcu_bootloader/src/property/: property.h
  group source/property/src
    ../../../../../middleware/mcu_bootloader/src/property/src/: property_imx.c
  group source/utilities
    ../../../../../middleware/mcu_bootloader/src/utilities/: fsl_assert.h fsl_rtos_abstraction.h vector_table_info.h
  group source/utilities/src
    ../../../../../middleware/mcu_bootloader/src/utilities/src/: debug_util.c fsl_assert.c fsl_rtos_abstraction.c
  group startup
    ../../../../../middleware/mcu_bootloader/src/startup/: ar_asm_macros.h startup.c
    ../../../../../middleware/mcu_bootloader/targets/MIMXRT1052/src/startup/iar/: startup_MIMXRT1052.s
