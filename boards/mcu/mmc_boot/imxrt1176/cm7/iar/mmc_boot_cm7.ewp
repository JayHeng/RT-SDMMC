# IAR project mmc_boot_cm7.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1176DVMAA_cm7; CPU_IS_ARM_CORTEX_M7=1; BL_TARGET_RAM; MIMXRT1176; SDK_OS_BAREMETAL
  ICCARM.CCDiagSuppress: Pa082,Pe177,Pe186,Ms014,Pa182
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMXRT1176; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../middleware/mcu_bootloader/src/bootloader; ../../../../../../middleware/mcu_bootloader/src/include; ../../../../../../middleware/mcu_bootloader/src/memory; ../../../../../../middleware/mcu_bootloader/src/memory/src; ../../../../../../middleware/mcu_bootloader/src/startup; ../../../../../../middleware/mcu_bootloader/src/property; ../../../../../../middleware/mcu_bootloader/src/utilities; ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1176/src; ../../../../../../middleware/mcu_bootloader/src; ../../../../../../middleware/mcu_bootloader/src/drivers; ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/inc; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/include; ../../../../../../middleware/mcu_bootloader/src/drivers/microseconds; ../../../../../../middleware/mcu_bootloader/src/drivers/ocotp; ../../../../../../CMSIS/Core/Include; ../../../../../../middleware/mcu_bootloader/src/drivers/usdhc; ../../../../../../components/osa; ../../../../../../components/lists
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  AARM.AUserIncludes: ../../../../../../middleware/mcu_bootloader/src/startup
  OBJCOPY.OOCOutputFile: mmc_boot_cm7.srec
  ILINK.IlinkOutputFile: mmc_boot_cm7.out
  ILINK.IlinkIcfFile: MIMXRT1176_ram_flashloader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cachel1_armv7.h cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.h
    ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1176/src/startup/: system_MIMXRT1176_cm7.c
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_anatop_ai.c fsl_anatop_ai.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_memory.h fsl_pmu.c fsl_pmu.h
  group MIMXRT1176
    ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1176/src/: bootloader_config.h clock_cfg_MIMXRT1176.c external_memory_property_map_MIMXRT1176.c fusemap.h hardware_init_MIMXRT1176.c memory_config.h memory_map_MIMXRT1176.c peripherals_pinmux.h sdmmc_config_MIMXRT1176.c sdmmc_convert_MIMXRT1176.c sdmmc_init.h sram_init_MIMXRT1176.c target_config.h
  group source/bootloader
    ../../../../../../middleware/mcu_bootloader/src/bootloader/: bl_context.h bl_shutdown_cleanup.h bootloader.h
  group source/bootloader/src
    ../../../../../../middleware/mcu_bootloader/src/bootloader/src/: bl_context.c bl_exception_handler.c bl_main.c bl_shutdown_cleanup.c
  group source/drivers/microseconds
    ../../../../../../middleware/mcu_bootloader/src/drivers/microseconds/: microseconds.h
    ../../../../../../middleware/mcu_bootloader/src/drivers/microseconds/src/: microseconds_pit.c
  group source/drivers/sdmmc
    ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/src/: fsl_mmc.c fsl_sd.c fsl_sdmmc_common.c
    ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/inc/: fsl_mmc.h fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
    ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/port/usdhc/polling/: fsl_sdmmc_host.c
  group source/drivers/usdhc
    ../../../../../../middleware/mcu_bootloader/src/drivers/usdhc/: bl_usdhc.c bl_usdhc.h
  group source/include
    ../../../../../../middleware/mcu_bootloader/src/include/: bootloader_common.h bootloader_core.h
  group source/memory
    ../../../../../../middleware/mcu_bootloader/src/memory/: memory.h
  group source/memory/src
    ../../../../../../middleware/mcu_bootloader/src/memory/src/: memory.c mmc_memory.c mmc_memory.h normal_memory.c normal_memory.h pattern_fill.h pattern_fill.s sd_memory.c sd_memory.h sram_init.h
  group source/property
    ../../../../../../middleware/mcu_bootloader/src/property/: property.h
  group source/property/src
    ../../../../../../middleware/mcu_bootloader/src/property/src/: property_imx.c
  group source/utilities
    ../../../../../../middleware/mcu_bootloader/src/utilities/: fsl_assert.h fsl_rtos_abstraction.h vector_table_info.h
  group source/utilities/src
    ../../../../../../middleware/mcu_bootloader/src/utilities/src/: debug_util.c fsl_assert.c fsl_rtos_abstraction.c
  group startup
    ../../../../../../middleware/mcu_bootloader/src/startup/: ar_asm_macros.h startup.c
    ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1176/src/startup/iar/: startup_MIMXRT1176_cm7.s
