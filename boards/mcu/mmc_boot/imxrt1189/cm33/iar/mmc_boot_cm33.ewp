# IAR project mmc_boot_cm33.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M33 NXP MIMXRT1189xxx8_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1189CVM8B_cm33; CPU_IS_ARM_CORTEX_M33=1; BL_TARGET_RAM; MIMXRT1189; USB_STACK_BM; SDK_OS_BAREMETAL
  ICCARM.CCDiagSuppress: Pa082,Pe177,Pe186,Ms014,Pa182
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMXRT1189; ../../../../../../devices/MIMXRT1189/drivers; ../../../../../../middleware/mcu_bootloader/src/bm_usb; ../../../../../../middleware/mcu_bootloader/src/autobaud; ../../../../../../middleware/mcu_bootloader/src/bootloader; ../../../../../../middleware/mcu_bootloader/src/crc; ../../../../../../middleware/mcu_bootloader/src/include; ../../../../../../middleware/mcu_bootloader/src/memory; ../../../../../../middleware/mcu_bootloader/src/memory/src; ../../../../../../middleware/mcu_bootloader/src/startup; ../../../../../../middleware/mcu_bootloader/src/packet; ../../../../../../middleware/mcu_bootloader/src/property; ../../../../../../middleware/mcu_bootloader/src/sbloader; ../../../../../../middleware/mcu_bootloader/src/utilities; ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1189/src; ../../../../../../middleware/mcu_bootloader/src; ../../../../../../middleware/mcu_bootloader/src/drivers; ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nor; ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi; ../../../../../../middleware/mcu_bootloader/src/drivers/serial_nor_eeprom; ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/inc; ../../../../../../middleware/mcu_bootloader/src/drivers/semc; ../../../../../../middleware/mcu_bootloader/src/drivers/nand_ecc; ../../../../../../middleware/mcu_bootloader/src/security/keyblob; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/include; ../../../../../../middleware/mcu_bootloader/src/drivers/semc_nand; ../../../../../../middleware/mcu_bootloader/src/drivers/microseconds; ../../../../../../middleware/mcu_bootloader/src/drivers/flexspi_nand; ../../../../../../middleware/mcu_bootloader/src/drivers/edgelock; ../../../../../../CMSIS/Core/Include; ../../../../../../middleware/mcu_bootloader/src/drivers/usdhc; ../../../../../../middleware/usb/output/npw/device_config/ehci; ../../../../../../middleware/usb/phy; ../../../../../../components/osa; ../../../../../../components/lists
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  AARM.AUserIncludes: ../../../../../../middleware/mcu_bootloader/src/startup
  OBJCOPY.OOCOutputFile: flashloader.srec
  ILINK.IlinkOutputFile: flashloader_cm33.out
  ILINK.IlinkIcfFile: MIMXRT1189_ram_flashloader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group device
    ../../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group drivers
    ../../../../../../devices/MIMXRT1189/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_iomuxc.h fsl_lpspi.c fsl_lpspi.h fsl_lpuart.c fsl_lpuart.h fsl_memory.h fsl_pmu.c fsl_pmu.h fsl_rgpio.c fsl_rgpio.h
  group MIMXRT1189
    ../../../../../../middleware/mcu_bootloader/targets/MIMXRT1189/src/: bootloader_config.h clock_cfg_MIMXRT1189.c external_memory_property_map_MIMXRT1189.c fusemap.h hardware_init_MIMXRT1189.c memory_config.h memory_map_MIMXRT1189.c peripherals_pinmux.h sdmmc_config_MIMXRT1189.c sdmmc_convert_MIMXRT1189.c sdmmc_init.h sram_init_MIMXRT1189.c target_config.h
  group source/bootloader
    ../../../../../../middleware/mcu_bootloader/src/bootloader/: bl_context.h bl_shutdown_cleanup.h bootloader.h
  group source/bootloader/src
    ../../../../../../middleware/mcu_bootloader/src/bootloader/src/: bl_context.c bl_exception_handler.c bl_main.c bl_shutdown_cleanup.c
  group source/drivers/microseconds
    ../../../../../../middleware/mcu_bootloader/src/drivers/microseconds/: microseconds.h
    ../../../../../../middleware/mcu_bootloader/src/drivers/microseconds/src/: microseconds_lpit.c
  group source/drivers/sdmmc
    ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/src/: fsl_mmc.c fsl_sd.c fsl_sdmmc_common.c
    ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/inc/: fsl_mmc.h fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
    ../../../../../../middleware/mcu_bootloader/src/drivers/sdmmc/port/usdhc/polling/: fsl_sdmmc_host.c
  group source/drivers/usdhc
    ../../../../../../middleware/mcu_bootloader/src/drivers/usdhc/: bl_usdhc.c bl_usdhc.h
  group source/include
    ../../../../../../middleware/mcu_bootloader/src/include/: bootloader_common.h bootloader_core.h
  group source/memory
    ../../../../../../middleware/mcu_bootloader/src/memory/: memory.h
  group source/memory/src
    ../../../../../../middleware/mcu_bootloader/src/memory/src/: memory.c mmc_memory.c mmc_memory.h normal_memory.c normal_memory.h pattern_fill.h pattern_fill.s sd_memory.c sd_memory.h sram_init.h
  group source/property
    ../../../../../../middleware/mcu_bootloader/src/property/: property.h
  group source/property/src
    ../../../../../../middleware/mcu_bootloader/src/property/src/: property_imx.c
  group source/utilities
    ../../../../../../middleware/mcu_bootloader/src/utilities/: fsl_assert.h fsl_rtos_abstraction.h vector_table_info.h
  group source/utilities/src
    ../../../../../../middleware/mcu_bootloader/src/utilities/src/: debug_util.c fsl_assert.c fsl_rtos_abstraction.c
  group startup
    ../../../../../../middleware/mcu_bootloader/src/startup/: ar_asm_macros.h startup.c
    ../../../../../../devices/MIMXRT1189/iar/: startup_MIMXRT1189_cm33.s
